# Keil uVision project prejoin.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L151C6 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: periodic +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32L1XX_MD CFG_lmic_clib CFG_DEBUG CFG_eu868 CFG_wimod_board CFG_sx1272_radio
  c include: ../../lmic;../../stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group app
    ./: main.c sensor.c
  group lmic
    ../../lmic/: aes.c hal.h lmic.c lmic.h lorabase.h oslmic.c oslmic.h radio.c
  group stm32
    ../../stm32/: debug.c debug.h hal.c hw.c hw.h startup_stm32l1xx_md_keil.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
software components: CMSIS:CORE 3.30.0
